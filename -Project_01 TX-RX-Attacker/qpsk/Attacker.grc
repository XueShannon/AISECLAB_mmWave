options:
  parameters:
    author: User
    generate_options: qt_gui
    id: Attacker
    output_language: python
    title: Attacker
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '22000000'
  states: {}
- name: bits_per_clock
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bits_per_pack
  id: variable
  parameters:
    value: '1'
  states: {}
- name: centerfreq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: filter_taps
  id: variable
  parameters:
    value: firdes.low_pass(1,samp_rate,samp_rate/(2*decimation), transition_bw)
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[1,1,0,0,1,1]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 22e5
  states: {}
- name: samp_rate_clock
  id: variable
  parameters:
    value: samp_rate*2
  states: {}
- name: sps
  id: variable_qtgui_range
  parameters:
    label: sample/symbol
    start: '1'
    step: '1'
    stop: '500'
    value: '100'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: threshold
    start: '0.01'
    step: '0.1'
    stop: '1'
    value: '0.9'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '200'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2*math.pi*centerfreq/samp_rate
    min_freq: '-2*math.pi*centerfreq/samp_rate'
    w: '0.05'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\AISECLAB\Desktop\AISECLAB_mmWave\qpsk\attacker.data
    type: complex
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '1'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '1'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '0'
    sps: sps
    symbols: preamble
    threshold: threshold
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: centerfreq
    decim: '1'
    samp_rate: samp_rate
    taps: filter_taps
    type: ccc
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_0_0_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import itertools
  states: {}
- name: import_0_1_0_0
  id: import
  parameters:
    imports: import itertools
  states: {}
- name: qtgui_sink_x_1_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidth
    fc: centerfreq
    fftsize: '4096'
    name: '"output_1"'
    rate: '50'
    showrf: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"output_after_estimator"'
    size: '1024'
    srate: samp_rate
    tr_tag: '"t0"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"output_directly"'
    size: '1024'
    srate: samp_rate
    tr_tag: '"t0"'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '22000000'
    center_freq0: '2400000000'
    clock_rate: 120e6
    clock_source0: external
    dev_addr: '"addr=192.168.10.6"'
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bandwidth
    center_freq0: centerfreq
    clock_rate: 120e6
    clock_source0: external
    dc_offs_enb0: auto
    dev_addr: '"addr = 192.168.10.8"'
    gain0: '20'
    iq_imbal_enb0: auto
    rx_agc0: Disabled
    samp_rate: '2200000'
    sd_spec0: A:0
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_delay_0, '0', digital_corr_est_cc_0, '0']
- [blocks_float_to_complex_0_0, '0', uhd_usrp_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_float_to_complex_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_sink_x_1_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_corr_est_cc_0, '0', analog_pll_carriertracking_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
