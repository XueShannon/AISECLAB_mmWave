options:
  parameters:
    author: iar
    generate_options: qt_gui
    id: hash_bits_Attacker
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: MC_data
  id: variable
  parameters:
    value: list(np.repeat(data,2))
  states: {}
- name: bits_per_clock
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bits_per_pack
  id: variable
  parameters:
    value: '1'
  states: {}
- name: centerfreq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: clock
  id: variable
  parameters:
    value: '"010101"'
  states: {}
- name: data
  id: variable
  parameters:
    value: '[1,0,1,0]'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Delay
    rangeType: int
    start: '-10000'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: filter_taps
  id: variable
  parameters:
    value: firdes.low_pass(1,samp_rate,samp_rate/(2*decimation), transition_bw)
  states: {}
- name: frequency_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Frequency Offset
    start: '-5000'
    step: '1'
    stop: '5000'
    value: '0'
  states: {}
- name: interval
  id: variable
  parameters:
    value: list(itertools.repeat(0, 10))
  states: {}
- name: periodicity
  id: variable
  parameters:
    value: len(MC_data)+len(preamble)
  states: {}
- name: phase_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Phase Offset
    start: '0'
    step: 0.01*math.pi
    stop: 2*math.pi
    value: '0'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[1,1,1,0,0,0]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: tag_clock
  id: variable_tag_object
  parameters:
    key: pmt.intern("clock")
    offset: '0'
    src: pmt.intern("vecsrc")
    value: pmt.intern("0")
  states: {}
- name: tag_message
  id: variable_tag_object
  parameters:
    key: pmt.intern("t0")
    offset: '0'
    src: pmt.intern("vecsrc")
    value: pmt.intern("message start")
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '200'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '9000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: frequency_offset
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: phase_offset
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.005'
    init: '0'
    low: '0.4e-3'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: centerfreq
    decim: '1'
    samp_rate: samp_rate
    taps: filter_taps
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_0_0_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1_0_0
  id: import
  parameters:
    imports: import itertools
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tab1@2: 0,0,1,1'
    name: '"Attacker after Filter"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tab1@2: 0,1,1,1'
    name: '"Attacker After Threshold"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab1@1:0,0,1,1
    name: '"Attacker after Filter"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"t1"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 'tab1@1: 0,1,1,1'
    name: '"Attacker After Threshold"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"t1"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab1@0
    label1: received
    label3: delay
    name: '"Attacker Received Directly"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"t1"'
    type: complex
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,2
    label0: Data
    num_tabs: '1'
  states: {}
- name: tab1
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,2
    label0: Time Directly
    label1: Time
    label2: Frequency
    num_tabs: '3'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 22e6
    center_freq0: centerfreq
    dev_addr: '"addr = 192.168.10.6"'
    gain0: '0'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 22e6
    center_freq0: centerfreq-1000
    dev_addr: '"addr = 192.168.10.7"'
    gain0: '0.4'
    gain_type0: normalized
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_phase_shift_0, '0']
- [blocks_phase_shift_0, '0', blocks_delay_0, '0']
- [blocks_phase_shift_0, '0', qtgui_time_sink_x_0_2, '1']
- [blocks_threshold_ff_0, '0', blocks_float_to_complex_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_1, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_1, '0', qtgui_time_sink_x_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
