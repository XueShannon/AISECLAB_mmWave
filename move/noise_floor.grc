options:
  parameters:
    author: iar
    generate_options: qt_gui
    id: noise_floor
    output_language: python
    title: Noise Floor
  states: {}

blocks:
- name: freq_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Freq. Off.
    start: '-0.25'
    step: '0.0001'
    stop: '0.25'
    value: '0'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Noise Power
    start: '-50'
    step: '1'
    stop: '10'
    value: '-50'
  states: {}
- name: path_loss
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Path Loss (dB)
    start: '0'
    step: '5'
    stop: '140'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Time Off.
    start: '0.9999'
    step: '0.00001'
    stop: '1.0001'
    value: '1.0'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_off
    freq_offset: freq_off
    noise_voltage: sps * 10.0**(noise/10.0)
    seed: '0'
    taps: 10.0**(-path_loss/20.0)
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 22e6
    center_freq0: 2.4e9
    dev_addr: '"addr = 192.168.10.5"'
    gain0: '1'
    gain_type0: normalized
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [channels_channel_model_0, '0', qtgui_const_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', channels_channel_model_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
