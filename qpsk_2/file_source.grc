options:
  parameters:
    author: iar
    generate_options: qt_gui
    id: QPSK_simulation_3TX
    output_language: python
    title: QPSK Simulation 3TX
  states: {}

blocks:
- name: am
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1.6'
  states: {}
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: centerfreq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: data
  id: variable
  parameters:
    value: '[0]*4+[1,0,1,0]'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '400'
    value: '231'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Freq. Off.
    start: '-0.25'
    step: '0.0001'
    stop: '0.25'
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Noise Power
    start: '-50'
    step: '1'
    stop: '10'
    value: '-30'
  states: {}
- name: path_loss
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Path Loss (dB)
    start: '0'
    step: '5'
    stop: '140'
    value: '30'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0x70, 0x72, 0x65, 0x61, 0x6D, 0x62, 0x6C, 0x65]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Time Off.
    start: '0.9999'
    step: '0.00001'
    stop: '1.0001'
    value: '1.0'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: variable_adaptive_algorithm
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\AISECLAB\Desktop\AISECLAB_mmWave\qpsk_2\receiver_3.data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: C:\Users\AISECLAB\Desktop\AISECLAB_mmWave\qpsk_2\attacker_8.data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: am
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: 'TX D5: transmitting bit'
    repeat: 'True'
    type: byte
    vector: preamble+data
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    comment: 'TX D6: transmitting bit'
    repeat: 'True'
    type: byte
    vector: preamble+data
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    comment: 'TX D3: transmitting bit'
    repeat: 'True'
    type: byte
    vector: preamble+data
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: qpsk
    fmax: '0'
    fmin: '0'
    loop_bw: excess_bw
  states: {}
- name: digital_constellation_receiver_cb_0_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: qpsk
    fmax: '0'
    fmin: '0'
    loop_bw: excess_bw
  states: {}
- name: digital_constellation_receiver_cb_0_0_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: qpsk
    fmax: '0'
    fmin: '0'
    loop_bw: excess_bw
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm
    num_taps: '15'
    sps: '2'
    training_sequence: preamble
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, preamble=1.0, match=[1,1]):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.preamble = preamble
              self.match = match
              self.count = 0
              self.error = 0
              self.len = len(match)
              self.step = 1
              self.time = time.time()

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if time.time() - self.time < 1:
                  return (len(input_items[0]))
              for x in input_items[0]:
                  match self.step:
                      case 1:
                          if x == 0:
                              self.count = self.count + 1
                          else:
                              self.count = 0
                          if self.count >= self.preamble*8:
                              self.step = 2
                              self.count = 0

                      case 2:                     
                          if x != self.match[self.count]:
                              self.error = self.error + 1

                          self.count = self.count + 1
                          
                          if self.count >= self.len:
                              print("symbol error rate:")
                              print(self.error/self.len*100)
                              print("%")
                              self.step = 1
                              self.count = 0
                              self.error = 0
                              self.time = time.time()     

              return (len(input_items[0]))
    match: '[1,0,1,1,0,1,1,0,1,1,1,1,1,1,0,0,1,0,1,1,0,1,0,1,1,1,1,0,1,0,1,1,0,1,1,0,1,1,1,1,1,1,0,1,0,1,1,1,0,1,0,1,1,1,1,1,1,0,0,1,1,0,0,0,0,0,0,0,0,1,0,1,0,1,1,1,1,1,0,0,0,1,0,1,1,1,0,1,1,0,0,0,1,1,0,0,1,1,1,1,1,1,0,1,1,1,0,0,1,0,0,0,0,1,0,0,0,0,0,0,1,1,0,0,0,0,0,1,0,1,1,1,0,1,0,1,0,0,1,0,0,0,1,1,1,0,1,1,0,0,0,1,1,0,1,1,0,0,0,1] + [0,1,1,1,0,0,0,0,0,1,1,1,0,0,1,0,0,1,1,0,0,1,0,1,0,1,1,0,0,0,0,1,0,1,1,0,1,1,0,1,0,1,1,0,0,0,1,0,0,1,1,0,1,1,0,0,0,1,1,0,0,1,0,1]'
    preamble: '50'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The CMA equalizer has been
      replaced by a Linear Equalizer
      and an Adaptive Algorithm for
      version 3.9
    note: CMA equalizer replaced
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"D5 constellation after processing"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    marker2: '0'
    marker3: '0'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
    width1: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 2,1,1,1
    label1: Tx Bits
    label2: D3
    label3: D6
    label4: D3
    name: raw
    nconnections: '2'
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
    width1: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"2"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"1"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 22e6
    center_freq0: centerfreq
    dev_addr: '"addr = 192.168.10.5"'
    gain0: '1'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 22e6
    center_freq0: centerfreq
    dev_addr: '"addr = 192.168.10.8"'
    gain0: '1'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 22e6
    center_freq0: centerfreq
    dev_addr: '"addr = 192.168.10.7"'
    gain0: '1'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 22e6
    center_freq0: centerfreq
    comment: 'RX D4: Receiving bit'
    dev_addr: '"addr = 192.168.10.3"'
    gain0: '1'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [blocks_add_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_0_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', digital_constellation_receiver_cb_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_1, '0']
- [blocks_file_source_1, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0, '0', digital_constellation_receiver_cb_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_1, '0', blocks_delay_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', blocks_char_to_float_0_0_1, '0']
- [blocks_vector_source_x_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_x_0_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_vector_source_x_0_0_0_0, '0', digital_constellation_modulator_0_0_0, '0']
- [digital_constellation_modulator_0, '0', uhd_usrp_sink_0_0, '0']
- [digital_constellation_modulator_0_0, '0', uhd_usrp_sink_0_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', uhd_usrp_sink_0_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [digital_constellation_receiver_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_receiver_cb_0_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [uhd_usrp_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
